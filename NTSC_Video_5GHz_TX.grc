options:
  parameters:
    category: Custom
    generate_options: qt_gui
    id: top_block
    output_language: python
    run_options: run
  states: {}

blocks:
- name: bandwidth
  id: variable
  parameters:
    value: 2e6
  states: {}
- name: frequency_carrier
  id: variable
  parameters:
    value: 5760e6
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 2 * bandwidth
  states: {}
- name: NTSC_Constants
  id: epy_module
  parameters:
    source_code: "Line = 0\r\n\r\n# NTSC SIGNAL TIMING (in sec.)\r\nHORIZONTAL_SYNC_DURATION = 4.7 * 0.000001\r\nBACK_PORCH_DURATION  = 4.7  * 0.000001\r\n#define VIDEO_DURATION 52.6  * 0.000001\r\n#define FRONT_PORCH_DURATION 1.5 * 0.000001\r\n#define LINE_DURATION 63.5 * 0.000001\r\n\r\n\r\n\r\n# NTSC SIGNAL LEVELS ---------------------*/\r\nBLACK_LEVEL = -0.02\r\nWHITE_LEVEL = 0.06\r\nHORIZONTAL_SYNC_THRESHOLD = -0.020\r\nHORIZONTAL_SYNC_LEVEL = -0.04\r\nBACK_PORCH_LEVEL = -0.015\r\nFRONT_PORCH_LEVEL = -0.015\r\nEQUALISING_LEVEL = -0.015\r\nVERTICAL_SYNC_LEVEL = -0.04\r\n\r\n\r\n\r\n#NTSC LINES FEATURES -------------------*/\r\n#define NBR_VIDEO_LINES 240\r\n#define NBR_EQUALISING_LINES 3\r\n#define NBR_VERTICAL_SYNC_LINES 21\r\n#define X_WIDTH 360\r\n#define Y_HEIGHT 240\r\n\r\n\r\n\r\n# NTSC SIGNAL STATES -------------------*/\r\n#define IDLE 1\r\n#define LINES_TRANSMISSION 2\r\n#define FRONT_PORCH 3\r\n#define HORIZONTAL_SYNC 4\r\n#define BACK_PORCH 5\r\n#define VIDEO 6\r\n#define VERTICAL_SYNC 7\r\n#define EQUALISING 8\r\n#define SERRATION 9\r\n#define BLANKING 10\r\n#define EVEN 1\r\n#define ODD 0\r\n# this module will be imported in the into your flowgraph"
  states: {state: disabled}
- name: NTSC_transmitter_c_0
  id: NTSC_transmitter_c
  parameters:
    samp_rate: samp_rate
  states: {state: disabled}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: frequency_carrier
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_COS_WAVE
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: float
  states: {}
- name: blocks_null_source_0
  id: blocks_null_source
  parameters:
    type: complex
  states: {state: disabled}
- name: blocks_throttle_0_0_1
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: float
  states: {state: disabled}
- name: blocks_vco_c_0_1
  id: blocks_vco_c
  parameters:
    amplitude: '1'
    samp_rate: samp_rate
    sensitivity: 200e6
  states: {state: disabled}
- name: epy_block_0
  id: epy_block
  parameters:
    OutputDirectory: '"Users\Chris\Documents\ECE1270"'
    _source_code: "\"\"\"\nEmbedded Python Blocks:\n\nEach time this file is saved, GRC will instantiate the first class it finds\nto get ports and parameters of your block. The arguments to __init__  will\nbe the parameters. All of them are required to have default values!\n\"\"\"\n\nimport numpy as np\nfrom gnuradio import gr\nfrom moviepy.editor import VideoFileClip\nimport moviepy\nimport skimage\nimport numpy as np\nimport os\n\n\nclass blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block\n    \"\"\"Embedded Python Block example - a simple multiply const\"\"\"\n\n    def __init__(self, filename = \"\", OutputDirectory = \"\"):  # only default arguments here\n        \"\"\"arguments to this function show up as parameters in GRC\"\"\"\n        gr.sync_block.__init__(\n            self,\n            name='Embedded Python Block',   # will show up in GRC\n            in_sig=[],\n            out_sig=[np.float32]\n        )\n        # if an attribute with the same name as a parameter is found,\n        # a callback is registered (properties work, too).\n        self.filename = filename\n        self.OutputDirectory = OutputDirectory\n        self.Line = 1\n        self.opened = 0\n        self.outvect = np.empty(0)\n\n\n    def work(self, input_items, output_items):\n\n\n\n        if os.listdir(\"frames\") == []:\n            vid = VideoFileClip(\"Snapchat-2027161104.mp4\")\n\n            # Convert to greyscale\n            vid = moviepy.video.fx.all.blackwhite(vid)\n            vid = vid.resize((720,486))\n\n            # extract sound and save to wav\n            sound = vid.audio\n            sound.write_audiofile('audioout.mp3')\n            TestFiles = np.empty([0], dtype='U50')\n\n            frames = 0\n\n            # Clear directory\n            dir = 'frames'\n            for file in os.scandir(dir):\n                os.remove(file.path)\n\n            # Extract frames and convert to array\n            for i in range(0, int(vid.duration * 30), 1):\n                framename = \"frames/frame\" + str(i) + \".jpeg\"\n                TestFiles.resize(TestFiles.size + 1)\n                TestFiles[TestFiles.size - 1] = framename\n                vid.save_frame(framename, float((i * vid.duration) / 30))\n\n                if (i == 0):\n                    vidvect = skimage.io.imread(TestFiles[0], as_gray=True).ravel()\n                else:\n                    vidvect = np.append(vidvect, skimage.io.imread(TestFiles[i], as_gray=True).ravel())\n                frames = frames + 1\n\n            firstrun = 0\n        if self.opened == 0:\n            self.opened = 1\n            i = 0\n            #FIX ORDER FILES ARE OPENED THEY ARE OPENING ALPHABETICALLY\n            for file in os.listdir(\"frames\"):\n                filename = \"frames/\" + file\n                if (i == 0):\n                    print(i)\n                    vidvect = skimage.io.imread(filename, as_gray=True).ravel()\n                    i = 1\n                else:\n                    print(file)\n                    vidvect = np.append(vidvect, skimage.io.imread(filename, as_gray=True).ravel())\n            self.outvect.resize(vidvect.size)\n            self.outvect = vidvect\n            self.outvect = np.reshape(self.outvect,(-1, 720))\n            print(self.outvect.shape)\n        print(output_items[0])\n        if output_items[0].size > self.outvect.shape[1]:\n            for k in range(self.outvect.shape[1]):\n                output_items[0][k] = self.outvect[self.Line, k]\n\n        self.Line = self.Line + 1\n        #\n        # if Line < vidvect.shape[0] - 1:\n        #     Line = Line + 1\n        # else:\n        #      Line = 0\n        return len(output_items[0])\n\n\n\n\n"
    filename: '"Users\Chris\Documents\ECE1270\Snapchat-2027161104.mp4"'
  states: {}
- name: epy_module_0
  id: epy_module
  parameters:
    source_code: '# this module will be imported in the into your flowgraph'
  states: {}
- name: iio_pluto_sink_0
  id: iio_pluto_sink
  parameters:
    attenuation1: '10.0'
    bandwidth: '20000000'
    buffer_size: '32768'
    cyclic: 'False'
    filter_source: '''Auto'''
    frequency: '2400000000'
    samplerate: samp_rate
    type: fc32
  states: {state: disabled}
- name: import_0_0
  id: import
  parameters:
    imports: import moviepy
  states: {}
- name: import_0_0_0
  id: import
  parameters:
    imports: import numpy
  states: {}
- name: import_0_0_0_0
  id: import
  parameters:
    imports: import scipy
  states: {}
- name: import_0_0_1
  id: import
  parameters:
    imports: import skimage
  states: {}
- name: note_0
  id: note
  parameters:
    note: Install Moviepy,scikit-image and other modules through CONDA prompt
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    size: '2000'
    srate: int(2e3)
    type: float
    ymin: '0'
  states: {}
- name: qtgui_time_sink_x_1
  id: qtgui_time_sink_x
  parameters:
    size: '1024'
    srate: samp_rate
    type: float
  states: {}
- name: uhd_usrp_sink_0_0
  id: uhd_usrp_sink
  parameters:
    ant0: TX/RX
    ant1: TX/RX
    center_freq0: frequency_carrier
    center_freq1: frequency_carrier
    clock_rate: '0.0'
    dev_args: '""'
    gain0: '1000'
    gain1: '1000'
    len_tag_name: ''
    nchan: '2'
    samp_rate: samp_rate
    sync: sync
    type: fc32
  states: {state: disabled}

connections:
- [NTSC_transmitter_c_0, '0', blocks_throttle_0_0_1, '0']
- [analog_sig_source_x_0, '0', blocks_multiply_xx_0, '1']
- [blocks_multiply_xx_0, '0', qtgui_time_sink_x_1, '0']
- [blocks_null_source_0, '0', uhd_usrp_sink_0_0, '0']
- [blocks_throttle_0_0_1, '0', blocks_vco_c_0_1, '0']
- [blocks_vco_c_0_1, '0', uhd_usrp_sink_0_0, '1']
- [epy_block_0, '0', blocks_multiply_xx_0, '0']
- [epy_block_0, '0', qtgui_time_sink_x_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.3.0
